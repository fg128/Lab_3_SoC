# Keil uVision project DES_M0_SoC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: DES_M0_SoC +hex
  AfterMake: fromelf .\temp_files\DES_M0_SoC.axf --vhx --32x1 -o ROMcode.txt
  AfterMake: fromelf -cvf .\temp_files\DES_M0_SoC.axf -o .\temp_files\disasm.txt
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Basic Examples
    ./: main.c main-SysTick.c main-scanf.c
  group CMSIS Example
    ./: main-CMSIS.c
  group Common Files
    ./: cm0dsasm.s retarget.c
